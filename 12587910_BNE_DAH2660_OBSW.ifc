Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: fdbcdcd3-4276-4bd0-8d3b-814cdf877059, NumberOfSaves: 1]
File name: 0001
Time: 2025-01-20T08:27:09+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12587910_BNE_DAH2660_OBSW:28H2660B_BNE_12587910_DAH2660_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 443 mm; Depth: 388 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28H2660B_BNE_12587910_DAH2660_OBSW; sets with these values: 2
